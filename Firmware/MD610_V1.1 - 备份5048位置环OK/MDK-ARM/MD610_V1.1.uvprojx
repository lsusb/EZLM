# Keil uVision project MD610_V1.1.uvprojx, settings and files
target MD610_V1.1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MD610_V1_1 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,STM32F405xx,USE_STDPERIPH_DRIVER
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/Any/Inc;../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/F4xx/Inc;../MCSDK_v5.4.4-Full/MotorControl/MCSDK/UILibrary/Inc;../MCSDK_v5.4.4-Full/MotorControl/MCSDK/SystemDriveParams;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/Include;..\StdDriver;..\StdApp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Src/: system_stm32f4xx.c
    ./: startup_stm32f405xx.s
  group STMotorDriver
    ../Src/: motorcontrol.c mc_api.c motor_control_protocol.c mc_config.c mc_tasks.c regular_conversion_manager.c mc_math.c mc_interface.c stm32f4xx_mc_it.c mc_parameters.c ui_task.c user_interface.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group STMotorControl
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_curr_fdbk.c pwm_common.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c sto_pll_speed_pos_fdbk.c virtual_speed_sensor.c
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/F4xx/Src/: ics_f4xx_pwm_curr_fdbk.c
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/UILibrary/Src/: frame_communication_protocol.c ui_irq_handler.c usart_frame_communication_protocol.c
  group HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c
  group StdDriver
    ../StdDriver/: stm32f4xx_dma.c stm32f4xx_spi.c misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c
  group StdAPP
    ../StdApp/: spi.c as5048.c
  group MyApp
    ../Src/: main.c schedule.c board.c mc_svpwm.c drv8301.c led.c my_math.c control.c parameter.c
software components: CMSIS:CORE 5.5.0
